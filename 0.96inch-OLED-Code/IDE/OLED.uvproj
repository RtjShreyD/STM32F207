# Keil uVision project OLED.uvproj, settings and files
target OLED (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: OLED +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\SRC\Hardware\SPI;..\SRC\Hardware\IIC;..\SRC\Hardware\SSD1306;..\SRC\STM32F10x_LIB\CMSIS;..\SRC\STM32F10x_LIB\inc;..\SRC\USER;..\SRC\Hardware\delay
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Hardware
    ../SRC/Hardware/SPI/: SPI.c
    ../SRC/Hardware/SSD1306/: SSD1306.c Fonts.c
    ../SRC/Hardware/delay/: delay.c
    ../SRC/Hardware/IIC/: IIC.c
  group STM32F10x_LIB
    ../SRC/STM32F10x_LIB/CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
    ../SRC/STM32F10x_LIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c
  group USER
    ../SRC/USER/: Config.c main.c pnslogo.c
