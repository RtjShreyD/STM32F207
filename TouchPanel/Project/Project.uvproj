# Keil uVision project Project.uvproj, settings and files
target Open207V (ARM-ADS)
  device: STM32F207ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Project
  c define: STM32F2XX, USE_STDPERIPH_DRIVER
  c include: ..\User;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\User\SysTick;..\User\LCD;..\User\TouchPanel
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../User/: main.c stm32f2xx_it.c config.h
    ../User/LCD/: LCD.c AsciiLib.c
    ../User/TouchPanel/: TouchPanel.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/arm/: startup_stm32f2xx.s
  group StdPeriph_Driver
    ../Libraries/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_usart.c misc.c stm32f2xx_fsmc.c stm32f2xx_tim.c stm32f2xx_spi.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.c
  group Readme
    ../User/: readme.txt
