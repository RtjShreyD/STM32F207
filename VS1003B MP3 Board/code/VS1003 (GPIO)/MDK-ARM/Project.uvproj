# Keil uVision project Project.uvproj, settings and files
target Open207Z (ARM-ADS)
  device: STM32F207ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F2XX,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;..\USER;..\USER\VS1003
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../USER/: main.c
  group VS1003
    ../USER/VS1003/: vs1003.c
  group StdPeriph_Driver
    ../Libraries/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_spi.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/arm/: startup_stm32f2xx.s
