# Keil uVision project Project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F207ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F2XX
  c include: ..\User;..\Lib\CMSIS\CM3\CoreSupport;..\Lib\STM32F2xx_StdPeriph_Driver\inc;..\Lib\CMSIS\CM3\DeviceSupport\ST\STM32F2xx
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../User/: main.c fsmc_nor.c usart.c
  group StdPeriph_Driver
    ../Lib/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_usart.c stm32f2xx_rcc.c misc.c
  group CMSIS
    ../Lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Lib/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.c
  group Startup
    ../Lib/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/arm/: startup_stm32f2xx.s
