# Keil uVision project Project.uvproj, settings and files
target Open207V (ARM-ADS)
  device: STM32F207ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c define: STM32F2XX, USE_STDPERIPH_DRIVER
  c include: ..\User;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\_Common;..\Libraries\FatFS;..\Libraries\FatFS\option;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/arm/: startup_stm32f2xx.s
  group CMSIS
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.c
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group StdPeriph_Driver
    ../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_gpio.c stm32f2xx_usart.c stm32f2xx_rcc.c stm32f2xx_i2c.c stm32f2xx_sdio.c stm32f2xx_flash.c stm32f2xx_dma.c
  group FatFS
    ../Libraries/FatFS/: diskio.c ff.c
    ../Libraries/FatFS/option/: cc936.c
  group User
    ../User/: main.c stm32f2xx_it.c sdcard.c
    ../../_Common/: config.c usart.c
