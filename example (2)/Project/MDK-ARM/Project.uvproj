# Keil uVision project Project.uvproj, settings and files
target STM322xG_EVAL (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM322xG_EVAL +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_STM322xG_EVAL
  c include: ..\inc;..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\Libraries\STM32F2x7_ETH_Driver\inc;..\..\User;..\..\User\STM322xG_EVAL;..\..\User\Common;..\..\User\Third_Party\lwip_v1.3.2\src\include;..\..\User\Third_Party\lwip_v1.3.2\src\include\lwip;..\..\User\Third_Party\lwip_v1.3.2\src\include\netif;..\..\User\Third_Party\lwip_v1.3.2\src\include\ipv4;..\..\User\Third_Party\lwip_v1.3.2\port\STM32F2x7;..\..\User\Third_Party\lwip_v1.3.2\port\STM32F2x7\Standalone
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.c
  group MDK-ARM
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/arm/: startup_stm32f2xx.s
  group User
    ../src/: main.c netconf.c stm32f2x7_eth_bsp.c stm32f2xx_it.c fs.c serial_debug.c httpd_cgi_ssi.c httpd.c
  group LwIP
    ../../User/Third_Party/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../User/Third_Party/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../../User/Third_Party/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../User/Third_Party/lwip_v1.3.2/src/netif/: etharp.c loopif.c slipif.c
    ../../User/Third_Party/lwip_v1.3.2/port/STM32F2x7/Standalone/: ethernetif.c
  group STM32F2xx_StdPeriph_Driver
    ../../Libraries/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_usart.c misc.c stm32f2xx_adc.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_sdio.c stm32f2xx_syscfg.c stm32f2xx_i2c.c
  group STM32F2x7_ETH_Driver
    ../../Libraries/STM32F2x7_ETH_Driver/src/: stm32f2x7_eth.c
  group STM322xG_EVAL
    ../../User/: stm32_eval.c
    ../../User/STM322xG_EVAL/: stm322xg_eval_lcd.c
