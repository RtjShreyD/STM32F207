# Keil uVision project Project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F207ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\User;..\Lib\CMSIS\CM3\CoreSupport;..\Lib\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;..\Lib\STM32F2xx_StdPeriph_Driver\inc;..\User\ucCos_App;..\User\uC-CPU;..\User\uC-LIB;..\User\uCOS-II;..\User\uCOS-VIEW;..\User\GLCD;..\User\TouchPanel;..\User\uCGUI;..\User\uCGUI\Config;..\User\uCGUI\inc;..\uCGUI_LIB\USER\uCGUI\AntiAlias;..\uCGUI_LIB\USER\uCGUI\Config;..\uCGUI_LIB\USER\uCGUI\ConvertColor;..\uCGUI_LIB\USER\uCGUI\ConvertMono;..\uCGUI_LIB\USER\uCGUI\Core;..\uCGUI_LIB\USER\uCGUI\Font;..\uCGUI_LIB\USER\uCGUI\GUIDemo;..\uCGUI_LIB\USER\uCGUI\GUIDemo2;..\uCGUI_LIB\USER\uCGUI\JPEG;..\uCGUI_LIB\USER\uCGUI\JPEG\Image;..\uCGUI_LIB\USER\uCGUI\MemDev;..\uCGUI_LIB\USER\uCGUI\MultiLayer;..\uCGUI_LIB\USER\uCGUI\Widget;..\uCGUI_LIB\USER\uCGUI\WM
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../User/: main.c stm32f2xx_conf.h stm32f2xx_it.c
    ../User/ucCos_App/: uctsk_Task.c uctsk_OSView.c app_cfg.h includes.h
  group TouchPanel
    ../User/TouchPanel/: TouchPanel.c
  group Startup
    ../Lib/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/arm/: startup_stm32f2xx.s
  group StdPeriph_Driver
    ../Lib/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group CMSI|S
    ../User/: system_stm32f2xx.c
    ../Lib/CMSIS/CM3/CoreSupport/: core_cm3.c
  group uC-OS-II/Port
    ../User/uCOS-II/Ports/ARM-Cortex-M3/RealView/: os_cpu_c.c os_dbg.c os_cpu.h os_cpu_a.asm
  group uC-OS-II/Source
    ../User/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uC-OS-II/Config
    ../User/ucCos_App/: OS_AppHooks.c os_cfg.h
  group uC-OS-II/CPU
    ../User/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm cpu.h
    ../User/uC-CPU/: cpu_def.h
  group uC-OS-II/LIB/Source
    ../User/uC-LIB/: lib_mem.c lib_str.c lib_def.h lib_mem.h lib_str.h
  group uC-OS-II/LIB/Port
    ../User/uC-LIB/Ports/RealView/: lib_mem_a.asm
  group uC-OS-II/VIEW/Source
    ../User/uCOS-VIEW/Source/: os_view.c os_view.h
  group uC-OS-II/VIEW/Port
    ../User/uCOS-VIEW/Ports/ARM-Cortex-M3/Realview/: os_viewc.c os_viewc.h
  group uCOS-Ⅱ/GUI_X
    ../User/uCGUI/: GUI_X_uCOS.c GUI_X_Touch.c
  group uCGUI/GLCD
    ../User/GLCD/: AsciiLib.c GLCD.c GLCD_UCGUI.c
  group uCGUI/Config
    ../User/uCGUI/Config/: GUIConf.h GUITouchConf.h LCDConf.h
  group uCGUI/Demo
    ../User/uCGUI/uCGUIDemo/: GUIDEMO.c GUIDEMO_Automotive.c GUIDEMO_Bitmap4bpp.c GUIDEMO_Bitmap.c GUIDEMO_Circle.c GUIDEMO_ColorBar.c GUIDEMO_ColorList.c GUIDEMO_Cursor.c GUIDEMO_Dialog.c GUIDEMO_Font.c GUIDEMO_FrameWin.c GUIDEMO_Graph.c GUIDEMO_HardwareInfo.c GUIDEMO_Intro.c GUIDEMO_LUT.c GUIDEMO_MemDevB.c GUIDEMO_Messagebox.c GUIDEMO_Navi.c GUIDEMO_Polygon.c GUIDEMO_ProgBar.c GUIDEMO_Speed.c GUIDEMO_Touch.c GUIDEMO_WM.c MainTask.c MicriumLogo.c MicriumLogoWRed.c
  group uCGUI/Lib
    ../uCGUI_LIB/: uCGUI.lib
